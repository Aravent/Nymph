# Keil uVision project AirDwing Nymph.uvprojx, settings and files
target Nymph v1.1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nymph +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,STM32,STM32F40x,ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\Lib\CMSIS\inc;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Bsp;..\OsdkCore\inc;..\AnyLib\can;..\AnyLib\delay;..\AnyLib\oled;..\AnyLib\sys;..\AnyLib\usart;..\AnyLib\MALLOC;..\AnyLib\FATFS\exfuns;..\AnyLib\FATFS\src;..\AnyLib\SDIO;..\AnyLib\SPI;..\AnyLib\SRAM;..\AnyLib\W25QXX;..\AnyLib\USMART;..\AnyLib\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: cppforstm32.cpp main.cpp Activate.cpp VirtualRC.cpp HotPoint.cpp Receive.cpp driver.cpp MobileCommand.cpp LocalNavigation.cpp
  group Bsp
    ../Bsp/: BspUsart.cpp bsp.cpp timer.cpp
  group LIB
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Lib/CMSIS/src/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group DjiLib
    ../OsdkCore/src/: DJI_API.cpp DJI_App.cpp DJI_Camera.cpp DJI_Codec.cpp DJI_Flight.cpp DJI_Follow.cpp DJI_HardDriver.cpp DJI_HotPoint.cpp DJI_Link.cpp DJI_Logging.cpp DJI_Memory.cpp DJI_Mission.cpp DJI_VirtualRC.cpp DJI_WayPoint.cpp
  group AnyLib
    ../AnyLib/can/: can.cpp
    ../AnyLib/oled/: oled.cpp
    ../AnyLib/delay/: delay.cpp
    ../AnyLib/sys/: sys.cpp
    ../AnyLib/PWM/: pwm.cpp
    ../AnyLib/SDIO/: sdio_sdcard.cpp
    ../AnyLib/SPI/: spi.c
    ../AnyLib/W25QXX/: w25qxx.c
  group FATFS
    ../AnyLib/FATFS/exfuns/: exfuns.c fattester.c
    ../AnyLib/FATFS/src/: diskio.c ff.c
    ../AnyLib/FATFS/src/option/: cc936.c
  group MALLOC
    ../AnyLib/MALLOC/: malloc.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2
